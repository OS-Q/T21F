# Keil uVision project SDIO.uvprojx, settings and files
target SDIO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SDIO +hex
  AfterMake: fromelf.exe --bin -o ./SDIO.bin ./obj/SDIO.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\User;..\Lib\cmsis;..\Lib\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../User/: main.c usart.c sdcard.c stm32f10x_it.c
  group STLibs
    ../Lib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_flash.c misc.c stm32f10x_dma.c
  group CMSIS
    ../Lib/cmsis/: core_cm3.c
    ../User/: system_stm32f10x.c
  group startup
    ../Lib/startup/arm/: startup_stm32f10x_hd.s
software components: CMSIS:CORE 5.1.2
